# Keil uVision project osapp_dis_server.uvprojx, settings and files
target BLE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: osapp_dis_server +hex
  AfterMake: ..\..\..\..\..\..\tools\image_tool\dissemble.bat @L
  AfterMake: ..\..\..\..\..\..\tools\image_tool\bin_merge.exe ..\..\..\..\..\..\tools\image_tool\merge.ini binary\RAM_CODE binary\FLASH_CODE binary\NVDS_AREA ..\..\..\..\..\..\tools\image_tool\boot_ram.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: B_APP_BLE_OSAPP_DIS_SERVER
  c include: ..\..\osapp_dis_server;..\..\..\examples;..\..\..\..\ble;..\..\..\..\src;..\..\..\..\src\include;..\..\..\..\src\portable;..\..\..\..\src\portable\ARMCC\ARM_CM0;..\..\..\..\utils;..\..\..\..\..\config;..\..\..\..\..\baremetal\api;..\..\..\..\..\baremetal\src;..\..\..\..\..\..\ip;..\..\..\..\..\..\ip\ahi\api;..\..\..\..\..\..\ip\ble\hl\api;..\..\..\..\..\..\ip\ble\hl\inc;..\..\..\..\..\..\ip\ble\hl\src\gap;..\..\..\..\..\..\ip\ble\hl\src\gap\gapc;..\..\..\..\..\..\ip\ble\hl\src\gap\gapm;..\..\..\..\..\..\ip\ble\hl\src\gap\smpc;..\..\..\..\..\..\ip\ble\hl\src\gap\smpm;..\..\..\..\..\..\ip\ble\hl\src\gatt;..\..\..\..\..\..\ip\ble\hl\src\gatt\attc;..\..\..\..\..\..\ip\ble\hl\src\gatt\attm;..\..\..\..\..\..\ip\ble\hl\src\gatt\atts;..\..\..\..\..\..\ip\ble\hl\src\gatt\gattc;..\..\..\..\..\..\ip\ble\hl\src\gatt\gattm;..\..\..\..\..\..\ip\ble\hl\src\l2c;..\..\..\..\..\..\ip\ble\hl\src\l2c\l2cc;..\..\..\..\..\..\ip\ble\hl\src\l2c\l2cm;..\..\..\..\..\..\ip\ble\hl\src\prf;..\..\..\..\..\..\ip\ble\hl\src\rwble_hl;..\..\..\..\..\..\ip\ea\api;..\..\..\..\..\..\ip\em\api;..\..\..\..\..\..\ip\hci\api;..\..\..\..\..\..\ip\hci\src;..\..\..\..\..\..\ip\ble\profiles\anp;..\..\..\..\..\..\ip\ble\profiles\anp\anpc\api;..\..\..\..\..\..\ip\ble\profiles\anp\anpc\src;..\..\..\..\..\..\ip\ble\profiles\anp\anps\api;..\..\..\..\..\..\ip\ble\profiles\anp\anps\src;..\..\..\..\..\..\ip\ble\profiles\bas;..\..\..\..\..\..\ip\ble\profiles\bas\basc\api;..\..\..\..\..\..\ip\ble\profiles\bas\basc\src;..\..\..\..\..\..\ip\ble\profiles\bas\bass\api;..\..\..\..\..\..\ip\ble\profiles\bas\bass\src;..\..\..\..\..\..\ip\ble\profiles\blp;..\..\..\..\..\..\ip\ble\profiles\blp\blpc\api;..\..\..\..\..\..\ip\ble\profiles\blp\blpc\src;..\..\..\..\..\..\ip\ble\profiles\blp\blps\api;..\..\..\..\..\..\ip\ble\profiles\blp\blps\src;..\..\..\..\..\..\ip\ble\profiles\bxota;..\..\..\..\..\..\ip\ble\profiles\bxota\bxotac\api;..\..\..\..\..\..\ip\ble\profiles\bxota\bxotac\src;..\..\..\..\..\..\ip\ble\profiles\bxota\bxotas\api;..\..\..\..\..\..\ip\ble\profiles\bxota\bxotas\src;..\..\..\..\..\..\ip\ble\profiles\cpp;..\..\..\..\..\..\ip\ble\profiles\cpp\cppc\api;..\..\..\..\..\..\ip\ble\profiles\cpp\cppc\src;..\..\..\..\..\..\ip\ble\profiles\cpp\cpps\api;..\..\..\..\..\..\ip\ble\profiles\cpp\cpps\src;..\..\..\..\..\..\ip\ble\profiles\cscp;..\..\..\..\..\..\ip\ble\profiles\cscp\cscpc\api;..\..\..\..\..\..\ip\ble\profiles\cscp\cscpc\src;..\..\..\..\..\..\ip\ble\profiles\cscp\cscps\api;..\..\..\..\..\..\ip\ble\profiles\cscp\cscps\src;..\..\..\..\..\..\ip\ble\profiles\dis;..\..\..\..\..\..\ip\ble\profiles\dis\disc\api;..\..\..\..\..\..\ip\ble\profiles\dis\disc\src;..\..\..\..\..\..\ip\ble\profiles\dis\diss\api;..\..\..\..\..\..\ip\ble\profiles\dis\diss\src;..\..\..\..\..\..\ip\ble\profiles\find;..\..\..\..\..\..\ip\ble\profiles\find\findl\api;..\..\..\..\..\..\ip\ble\profiles\find\findl\src;..\..\..\..\..\..\ip\ble\profiles\find\findt\api;..\..\..\..\..\..\ip\ble\profiles\find\findt\src;..\..\..\..\..\..\ip\ble\profiles\glp;..\..\..\..\..\..\ip\ble\profiles\glp\glpc\api;..\..\..\..\..\..\ip\ble\profiles\glp\glpc\src;..\..\..\..\..\..\ip\ble\profiles\glp\glps\api;..\..\..\..\..\..\ip\ble\profiles\glp\glps\src;..\..\..\..\..\..\ip\ble\profiles\hrp;..\..\..\..\..\..\ip\ble\profiles\hrp\hrpc\api;..\..\..\..\..\..\ip\ble\profiles\hrp\hrpc\src;..\..\..\..\..\..\ip\ble\profiles\hrp\hrps\api;..\..\..\..\..\..\ip\ble\profiles\hrp\hrps\src;..\..\..\..\..\..\ip\ble\profiles\htp;..\..\..\..\..\..\ip\ble\profiles\htp\htpc\api;..\..\..\..\..\..\ip\ble\profiles\htp\htpc\src;..\..\..\..\..\..\ip\ble\profiles\htp\htpt\api;..\..\..\..\..\..\ip\ble\profiles\htp\htpt\src;..\..\..\..\..\..\ip\ble\profiles\lan;..\..\..\..\..\..\ip\ble\profiles\lan\lanc\api;..\..\..\..\..\..\ip\ble\profiles\lan\lanc\src;..\..\..\..\..\..\ip\ble\profiles\lan\lans\api;..\..\..\..\..\..\ip\ble\profiles\lan\lans\src;..\..\..\..\..\..\ip\ble\profiles\pasp;..\..\..\..\..\..\ip\ble\profiles\pasp\paspc\api;..\..\..\..\..\..\ip\ble\profiles\pasp\paspc\src;..\..\..\..\..\..\ip\ble\profiles\pasp\pasps\api;..\..\..\..\..\..\ip\ble\profiles\pasp\pasps\src;..\..\..\..\..\..\ip\ble\profiles\prox;..\..\..\..\..\..\ip\ble\profiles\prox\proxm\api;..\..\..\..\..\..\ip\ble\profiles\prox\proxm\src;..\..\..\..\..\..\ip\ble\profiles\prox\proxr\api;..\..\..\..\..\..\ip\ble\profiles\prox\proxr\src;..\..\..\..\..\..\ip\ble\profiles\rscp;..\..\..\..\..\..\ip\ble\profiles\rscp\rscpc\api;..\..\..\..\..\..\ip\ble\profiles\rscp\rscpc\src;..\..\..\..\..\..\ip\ble\profiles\rscp\rscps\api;..\..\..\..\..\..\ip\ble\profiles\rscp\rscps\src;..\..\..\..\..\..\ip\ble\profiles\scpp;..\..\..\..\..\..\ip\ble\profiles\scpp\scppc\api;..\..\..\..\..\..\ip\ble\profiles\scpp\scppc\src;..\..\..\..\..\..\ip\ble\profiles\scpp\scpps\api;..\..\..\..\..\..\ip\ble\profiles\scpp\scpps\src;..\..\..\..\..\..\ip\ble\profiles\tip;..\..\..\..\..\..\ip\ble\profiles\tip\tipc\api;..\..\..\..\..\..\ip\ble\profiles\tip\tipc\src;..\..\..\..\..\..\ip\ble\profiles\tip\tips\api;..\..\..\..\..\..\ip\ble\profiles\tip\tips\src;..\..\..\..\..\..\ip\ble\profiles\hogp;..\..\..\..\..\..\ip\ble\profiles\hogp\hogpbh\api;..\..\..\..\..\..\ip\ble\profiles\hogp\hogpbh\src;..\..\..\..\..\..\ip\ble\profiles\hogp\hogpd\api;..\..\..\..\..\..\ip\ble\profiles\hogp\hogpd\src;..\..\..\..\..\..\ip\ble\profiles\hogp\hogprh\api;..\..\..\..\..\..\ip\ble\profiles\hogp\hogprh\src;..\..\..\..\..\..\ip\ble\profiles\anc;..\..\..\..\..\..\ip\ble\profiles\anc\ancc;..\..\..\..\..\..\ip\ble\profiles\anc\ancc\src;..\..\..\..\..\..\ip\ble\profiles\anc\ancc\api;..\..\..\..\..\..\ip\ble\ll\src\rwble;..\..\..\..\..\..\ip\ble\ll\src\em;..\..\..\..\..\..\ip\ble\ll\src\llc;..\..\..\..\..\..\ip\ble\ll\src\lld;..\..\..\..\..\..\ip\ble\ll\src\llm;..\..\..\..\..\..\modules\common\api;..\..\..\..\..\..\modules\dbg\api;..\..\..\..\..\..\modules\display\api;..\..\..\..\..\..\modules\display\src;..\..\..\..\..\..\modules\ecc_p256\api;..\..\..\..\..\..\modules\h4tl\api;..\..\..\..\..\..\modules\ke\api;..\..\..\..\..\..\modules\ke\src;..\..\..\..\..\..\modules\nvds\api;..\..\..\..\..\..\modules\rf\api;..\..\..\..\..\..\modules\rwip\api;..\..\..\..\..\..\plf;..\..\..\..\..\..\plf\inc;..\..\..\..\..\..\plf\inc\cmsis;..\..\..\..\..\..\plf\bx_debug;..\..\..\..\..\..\plf\bx_debug\log;..\..\..\..\..\..\plf\bx_debug\log\RTT;..\..\..\..\..\..\plf\peripheral\;..\..\..\..\..\..\plf\peripheral\swint;..\..\..\..\..\..\plf\peripheral\ssi;..\..\..\..\..\..\plf\peripheral\ssi\app_qspi;..\..\..\..\..\..\plf\peripheral\ssi\app_spi;..\..\..\..\..\..\plf\peripheral\rtc;..\..\..\..\..\..\plf\peripheral\led;..\..\..\..\..\..\plf\peripheral\hw_ecc;..\..\..\..\..\..\plf\peripheral\flash;..\..\..\..\..\..\plf\peripheral\flash_cache;..\..\..\..\..\..\plf\peripheral\sleep_recovery;..\..\..\..\..\..\plf\peripheral\app_uart;..\..\..\..\..\..\plf\peripheral\app_dmac;..\..\..\..\..\..\plf\peripheral\app_hwecc;..\..\..\..\..\..\plf\peripheral\app_adc;..\..\..\..\..\..\plf\peripheral\app_gpio;..\..\..\..\..\..\plf\peripheral\app_iic;..\..\..\..\..\..\plf\peripheral\app_pwm;..\..\..\..\..\..\plf\peripheral\app_timer;..\..\..\..\..\..\plf\apollo_00;..\..\..\..\..\..\plf\apollo_00\src;..\..\..\..\..\..\plf\apollo_00\src\arch;..\..\..\..\..\..\plf\apollo_00\src\arch\boot\armcc;..\..\..\..\..\..\plf\apollo_00\src\arch\compiler\armcc;..\..\..\..\..\..\plf\apollo_00\src\arch\ll\;..\..\..\..\..\..\plf\apollo_00\src\build\ble-full\reg\fw;..\..\..\..\..\..\plf\apollo_00\src\jmp_table;..\..\..\..\..\..\plf\apollo_00\src\patch_list;..\..\..\..\..\..\plf\apollo_00\src\sleep;..\..\..\..\..\..\plf\apollo_00\src\inc;..\..\..\..\..\..\plf\apollo_00\src\arch\boot\armcc;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\adc;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\cache;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\charger;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\dmac;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\gpio;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\hwecc;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\iic;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\pwm;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\qspi;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\rtc;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\spi;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\uart;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\timer;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\clk_gate;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\modem;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\patch;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\periph_mngt;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\pshare;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\rc_calib;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\rst_gen;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\swint;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\sysctrl;..\..\..\..\..\..\plf\bx_debug\internal_log;..\..\..\..\..\..\app;..\..\..\..\..\freertos;..\..\..\..\..\..\fingerprint;..\..\..\..\..\..\fingerprint\algFp;..\..\..\..\..\..\fingerprint\logic;..\..\..\..\..\..\fingerprint\mafp;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\timer;..\..\..\..\..\..\plf\peripheral\microarray\uart;..\..\..\..\..\..\plf\peripheral\app_timer;..\..\..\..\..\..\fingerprint\mafp\algTop;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\adc;..\..\..\..\..\..\plf\peripheral\app_adc;..\..\..\..\..\..\plf\peripheral\microarray\flash;..\..\..\..\..\..\plf\peripheral\microarray\sensor;..\..\..\..\..\..\plf\peripheral\microarray\timer;..\..\osapp_uart_server;..\..\..\..\..\..\plf\peripheral\microarray\speaker;..\..\..\..\..\..\plf\peripheral\microarray\mfrc;..\..\..\..\..\..\plf\peripheral\microarray\oled;..\..\..\..\..\..\plf\peripheral\microarray\led;..\..\..\..\..\..\plf\peripheral\microarray\touch;..\..\..\..\..\..\plf\peripheral\microarray\sensor3403;..\..\..\..\..\microarray
  asm include: None
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x100000 size 0x30000
  scatter file: ..\..\..\..\..\..\plf\apollo_00\config\linker_script\armcc\fw_usr.txt
  link misc: --diag_suppress=L6314,L6329
..\..\..\..\..\..\plf\apollo_00\config\rom_syms_armcc.txt --datacompressor=off
  group Application
    ../../osapp_uart_server/: osapp_uart_server.c
  group Freertos
    ../../../../src/portable/MemMang/: heap_4.c
    ../../../../src/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../src/portable/ARMCC/ARM_CM0/: port.c
  group Core
    ../../../../../../plf/apollo_00/src/arch/boot/armcc/: startup_apollo_00.s
    ../../../../../../ip/ble/hl/src/prf/: prf.c prf_utils.c
    ../../../../../../ip/ble/ll/src/lld/: bx_lld_sleep.c
    ../../../../../../ip/ble/ll/src/rwble/: bx_rwble.c
    ../../../../utils/: ble_task.c os_bridge.c osapp_task.c osapp_utils.c task_init.c
    ../../../../: main.c
    ../../../../../microarray/: Hardware.c User.c Front.c
  group Profiles
    ../../../../../../ip/ble/profiles/anp/anpc/src/: anpc.c anpc_task.c
    ../../../../../../ip/ble/profiles/anp/anps/src/: anps.c anps_task.c
    ../../../../../../ip/ble/profiles/bas/basc/src/: basc.c basc_task.c
    ../../../../../../ip/ble/profiles/bas/bass/src/: bass.c bass_task.c
    ../../../../../../ip/ble/profiles/blp/blpc/src/: blpc.c blpc_task.c
    ../../../../../../ip/ble/profiles/blp/blps/src/: blps.c blps_task.c
    ../../../../../../ip/ble/profiles/bxota/bxotas/src/: bxotas.c bxotas_task.c
    ../../../../../../ip/ble/profiles/cpp/cppc/src/: cppc.c cppc_task.c
    ../../../../../../ip/ble/profiles/cpp/cpps/src/: cpps.c cpps_task.c
    ../../../../../../ip/ble/profiles/cscp/cscpc/src/: cscpc.c cscpc_task.c
    ../../../../../../ip/ble/profiles/cscp/cscps/src/: cscps.c cscps_task.c
    ../../../../../../ip/ble/profiles/dis/disc/src/: disc.c disc_task.c
    ../../../../../../ip/ble/profiles/dis/diss/src/: diss.c diss_task.c
    ../../../../../../ip/ble/profiles/find/findl/src/: findl.c findl_task.c
    ../../../../../../ip/ble/profiles/find/findt/src/: findt.c findt_task.c
    ../../../../../../ip/ble/profiles/glp/glpc/src/: glpc.c glpc_task.c
    ../../../../../../ip/ble/profiles/glp/glps/src/: glps.c glps_task.c
    ../../../../../../ip/ble/profiles/hogp/hogpbh/src/: hogpbh.c hogpbh_task.c
    ../../../../../../ip/ble/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
    ../../../../../../ip/ble/profiles/hogp/hogprh/src/: hogprh.c hogprh_task.c
    ../../../../../../ip/ble/profiles/hrp/hrpc/src/: hrpc.c hrpc_task.c
    ../../../../../../ip/ble/profiles/hrp/hrps/src/: hrps.c hrps_task.c
    ../../../../../../ip/ble/profiles/htp/htpc/src/: htpc.c htpc_task.c
    ../../../../../../ip/ble/profiles/htp/htpt/src/: htpt.c htpt_task.c
    ../../../../../../ip/ble/profiles/lan/lanc/src/: lanc.c lanc_task.c
    ../../../../../../ip/ble/profiles/lan/lans/src/: lans.c lans_task.c
    ../../../../../../ip/ble/profiles/pasp/paspc/src/: paspc.c paspc_task.c
    ../../../../../../ip/ble/profiles/pasp/pasps/src/: pasps.c pasps_task.c
    ../../../../../../ip/ble/profiles/prox/proxm/src/: proxm.c proxm_task.c
    ../../../../../../ip/ble/profiles/prox/proxr/src/: proxr.c proxr_task.c
    ../../../../../../ip/ble/profiles/rscp/rscpc/src/: rscpc.c rscpc_task.c
    ../../../../../../ip/ble/profiles/rscp/rscps/src/: rscps.c rscps_task.c
    ../../../../../../ip/ble/profiles/scpp/scppc/src/: scppc.c scppc_task.c
    ../../../../../../ip/ble/profiles/scpp/scpps/src/: scpps.c scpps_task.c
    ../../../../../../ip/ble/profiles/tip/tipc/src/: tipc.c tipc_task.c
    ../../../../../../ip/ble/profiles/tip/tips/src/: tips.c tips_task.c
    ../../../../../../ip/ble/profiles/anc/ancc/src/: ancc.c ancc_task.c
  group Modules
    ../../../../../../plf/apollo_00/src/arch/: arch_init.c
    ../../../../../../modules/dbg/src/: dbg.c dbg_mwsgen.c dbg_swdiag.c dbg_task.c
    ../../../../../../modules/display/src/: display.c display_task.c
    ../../../../../../modules/ecc_p256/src/: ecc_p256.c
    ../../../../../../modules/nvds/src/: nvds_in_ram.c nvds_tag.c nvds_task.c
    ../../../../../../modules/rwip/src/: rwip.c
    ../../../../../../modules/common/src/: bx_ring_queue.c
    ../../../../../../modules/rf/src/: rf_apollo.c
  group Utils
    ../../../../../../plf/apollo_00/src/jmp_table/: jump_table.c
    ../../../../../../plf/apollo_00/src/patch_list/: patch_test.c tx_test_end.c patch_list.s adv_int.c h4tl_patch.c prog_latency_patch.c set_adv_payload_31Byte_patch.c h4tl_read_start_skip_patch.c llm_end_evt_defer_patch.c
    ../../../../../../plf/apollo_00/src/sleep/: sys_sleep.c sys_sleep_ram.c
    ../../../../../../plf/bx_debug/: bx_dbg.c
    ../../../../../../plf/bx_debug/log/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../plf/bx_debug/log/: sim_log.c
    ../../../../../../plf/bx_debug/armcc/: bx_dbg_asm.s
    ../../../../../../plf/apollo_00/src/patch_list/armcc/: h4tl_patch_asm.s h4tl_read_start_patch_asm.s
  group Integration
    ../../../../../../plf/apollo_00/src/sys_integration/clk_gate/: clk_gate.c
    ../../../../../../plf/apollo_00/src/sys_integration/modem/: modem.c
    ../../../../../../plf/apollo_00/src/sys_integration/patch/: patch.c
    ../../../../../../plf/apollo_00/src/sys_integration/periph_mngt/: periph_mngt.c
    ../../../../../../plf/apollo_00/src/sys_integration/pshare/: pshare.c
    ../../../../../../plf/apollo_00/src/sys_integration/rc_calib/: rc_calib.c
    ../../../../../../plf/apollo_00/src/sys_integration/rst_gen/: rst_gen.c
    ../../../../../../plf/apollo_00/src/sys_integration/sysctrl/: sysctrl.c io_ctrl.c rf_reg_settings_apollo_00.c touch.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/cache/: cache_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/adc/: adc_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/charger/: charger.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/dmac/: dmac_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/gpio/: gpio_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/hwecc/: hwecc_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/iic/: iic_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/pwm/: pwm_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/qspi/: qspi_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/rtc/: rtc_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/spi/: spi_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/timer/: timer_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/uart/: uart_integration.c
  group Peripheral
    ../../../../../../plf/peripheral/app_adc/: app_adc.c
    ../../../../../../plf/peripheral/app_dmac/: app_dmac.c app_dmac_wrapper.c
    ../../../../../../plf/peripheral/app_gpio/: app_gpio.c
    ../../../../../../plf/peripheral/app_hwecc/: app_hwecc.c app_hwecc_wrapper.c
    ../../../../../../plf/peripheral/app_iic/: app_iic.c
    ../../../../../../plf/peripheral/app_pwm/: app_pwm.c
    ../../../../../../plf/peripheral/app_timer/: app_timer.c
    ../../../../../../plf/peripheral/app_uart/: app_uart.c
    ../../../../../../plf/peripheral/flash/: flash.c
    ../../../../../../plf/peripheral/flash_cache/: flash_cache.c
    ../../../../../../plf/peripheral/sleep_recovery/: periph_recovery.c
    ../../../../../../plf/peripheral/ssi/app_qspi/: app_qspi.c app_qspi_wrapper.c
    ../../../../../../plf/peripheral/ssi/app_spi/: app_spi.c
    ../../../../../../plf/peripheral/microarray/flash/: m_flash.c
    ../../../../../../plf/peripheral/microarray/sensor/: sensor_operation_afs121n.c
    ../../../../../../plf/peripheral/microarray/timer/: m_timer.c
    ../../../../../../plf/peripheral/microarray/uart/: m_uart.c
    ../../../../../../plf/peripheral/microarray/speaker/: common_lock_speaker.c
    ../../../../../../plf/peripheral/microarray/mfrc/: common_lock_mfrc.c
    ../../../../../../plf/peripheral/microarray/oled/: common_lock_oled.c
    ../../../../../../plf/peripheral/microarray/led/: common_lock_led.c
    ../../../../../../plf/peripheral/microarray/touch/: common_lock_bs81x.c
    ../../../../../../plf/peripheral/microarray/sensor3403/: common_lock_sensor3403.c
  group Config
    ../../../../../../plf/apollo_00/: bx_sys_config.h
  group algFp
    ../../../../../../fingerprint/algFp/: algApi.c CC_FPALG.c extract.c gaborFilter.c geometry.c imgProc.c match.c miscFunc.c
  group logic
    ../../../../../../fingerprint/logic/: fsm.c synoc.c system.c
  group mafp
    ../../../../../../fingerprint/mafp/: mafp_sensor.c malib.c platform.c policy.c sensor_hal.c sensor_identify.c sensor_sal.c sensor_utils.c tpls_mngr.c
    ../../../../../../fingerprint/mafp/algTop/: afs121.c calCorr.c removebkg.c

# Keil uVision project boot_ram.uvprojx, settings and files
target Boot_ram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: boot_ram_download
  AfterMake: fromelf --bin --output=boot_ram_download.bin .\Objects\%L
  AfterMake: fromelf -c -a -d -e -v -o boot_ram_download.asm .\Objects\%L
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG HW_BX_VERSION=2400
  c include: ..\..\bootloader;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include;.\clkg;.\dmac;.\flash;.\qspi;.\uart;.\uart_awo;.\user_file;.\log;.\log\RTT;..\..\..\..\ip\ble\ll;.\arch;.\arch\boot;.\arch\boot\armcc;.\arch\boot\armgcc;.\arch\compiler;.\arch\compiler\armcc;.\arch\compiler\armgcc;.\arch\compiler\iar;.\arch\ll;.\arch\ll\armcc;.\arch\ll\armgcc;.\rwip\api;.\sleep;.\nvds\api;.\reg\fw;.\common\api;..\boot_ram;.\;..\..\..\..\;..\..\..\..\plf;..\..\..\peripheral\flash_cache;..\..\..\peripheral;..\..\..\..\ip;..\..\..\apollo_00;..\boot_ram_download
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\boot_ram_scatter.txt
  group Core
    ./: boot_ram.c uart_download.c startup_uart_download.s pshare_rom.c bx_app_config.h
    ./uart/: uart.c
    ./log/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../boot_ram/: dma_for_qspi.c flash.c qspi.c
